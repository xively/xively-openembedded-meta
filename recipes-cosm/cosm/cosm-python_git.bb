require cosm-python.inc

SRCREV = "20c3c64de23453877a2d64e12d29c79122784e98"
PV = "0.0.1+git${SRCPV}"
PR = "r0"

LIC_FILES_CHKSUM = "file://README.rst;md5=21daffcaeefb264fe99922f728a565b7"
