require python-requests.inc

SRCREV = "v${PV}"

LIC_FILES_CHKSUM = "file://README.rst;md5=74c75b1ca7932ffb54dc2d3d185d8803 \
		    file://NOTICE;md5=a7fcf1dc2d13f4c1e901564711244fb4 \
		    file://LICENSE;md5=c858703330162aa799141655a10fe120"

