require python-pybbio.inc

SRCREV = "3be217a67e9a0c484287ccd6600db1630fc674e3"
PV = "0.5+git${SRCPV}"
PR = "r0"

LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=86d3f3a95c324c9479bd8986968f4327"
