require python-pybbio.inc
inherit distutils

SRCREV = "v${PV}"

LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=86d3f3a95c324c9479bd8986968f4327"
