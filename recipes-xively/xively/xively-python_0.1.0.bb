require xively-python.inc

SRCREV = "v${PV}-rc1"

LIC_FILES_CHKSUM = "file://README.rst;md5=0cefc39224f466fcb50777d27b067932"
