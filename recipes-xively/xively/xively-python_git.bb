require xively-python.inc

SRCREV = "bbc7418623c23eda025700ecbcacd563127ccbac"
PV = "0.1.0-rc0+git${SRCPV}"

LIC_FILES_CHKSUM = "file://README.rst;md5=4acf34fa9ed486b582ec9ab0492beda4"
